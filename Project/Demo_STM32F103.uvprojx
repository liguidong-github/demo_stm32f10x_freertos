# Keil uVision project Demo_STM32F103.uvprojx, settings and files
target Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo_STM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\STM32F10x_StdPeriph_Libraries;..\STM32F10x_StdPeriph_Libraries\STM32F10x_StdPeriph_Driver\src;..\STM32F10x_StdPeriph_Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Libraries\CMSIS\CM3\CoreSupport;..\STM32F10x_StdPeriph_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\FreeRTOS\Source;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\FreeRTOS\Source\portable\MemMang;..\FreeRTOS;..\User\Bsp;..\SEGGER_RTT\RTT
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c Task_LED.c Task_Log.c
  group Bsp
    ../User/Bsp/: bsp_gpio_led.c bsp_usart1.c
  group CMSIS
    ../STM32F10x_StdPeriph_Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../STM32F10x_StdPeriph_Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../STM32F10x_StdPeriph_Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Portable
    ../FreeRTOS/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group SEGGER_RTT
    ../SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Config
    ../FreeRTOS/: FreeRTOSConfig.h
    ../STM32F10x_StdPeriph_Libraries/: stm32f10x_conf.h
    ../SEGGER_RTT/RTT/: SEGGER_RTT_Conf.h
  group Template
    ../User/: Template.c
